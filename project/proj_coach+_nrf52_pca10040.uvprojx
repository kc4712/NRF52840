# Keil uVision project proj_coach+_nrf52_pca10040.uvprojx, settings and files
target nrf52832_xxaa_s132 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: F1_1_0_0_2 +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1
  c define: GC_COACH_FIT_PCB GC_COACH_FIT_HW_1_2 GC_NRF52_PAHR GC_NRF52_SPI_HR GC_NRF52_SPI_FLASH GC_NRF52_TWI GC_NRF52_DEV GC_NRF52_UART GREENCOMM_BT GREENCOMM_NUS BLE_STACK_SUPPORT_REQD BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_28 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET S132 NRF_LOG_USES_UART=1 NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0
  c include: ..\config\ble_app_uart_s132_pca10040;..\config;..\..\components\ble\ble_advertising;..\..\components\ble\ble_services\ble_nus;..\..\components\ble\ble_services\ble_ancs_c;..\..\components\ble\ble_db_discovery;..\..\components\ble\common;..\..\components\drivers_nrf\common;..\..\components\drivers_nrf\config;..\..\components\drivers_nrf\delay;..\..\components\drivers_nrf\gpiote;..\..\components\drivers_nrf\hal;..\..\components\drivers_nrf\pstorage;..\..\components\drivers_nrf\uart;..\..\components\libraries\button;..\..\components\libraries\scheduler;..\..\components\libraries\experimental_section_vars;..\..\components\libraries\fifo;..\..\components\libraries\fstorage;..\..\components\libraries\fstorage\config;..\..\components\libraries\timer;..\..\components\libraries\uart;..\..\components\libraries\util;..\..\components\softdevice\common\softdevice_handler;..\..\components\softdevice\s132\headers;..\..\components\softdevice\s132\headers\nrf52;..\..\components\toolchain;..\..\bsp;..\..\external\segger_rtt;..\..\components\drivers_nrf\clock;..\..\components\libraries\timer;..\..\components\drivers_nrf\delay;..\..\ble_app_uart_hkim;..\....\..\components\drivers_nrf\rtc;..\..\components\ble\ble_services\ble_dfu;..\..\components\libraries\bootloader_dfu;..\..\components\ble\device_manager;..\..\components\ble\device_manager\config;..\..\..\..\..\..\components\ble\device_manager;..\..\components\libraries\trace;..\..\components\toolchain\CMSIS\include;../include;..\..\components\drivers_nrf\twi_master;..\..\components\drivers_nrf\spi_master;..\..\components\drivers_nrf\ppi;..\..\components\drivers_nrf\gpiote;../gc_include;;..\..\components\drivers_nrf\saadc;C:\Keil_v5\ARM\Pack\NordicSemiconductor\RTT;..\..\external\segger_rtt;..\..\components\drivers_nrf\timer
  asm define: GC_NRF52_SPI_FLASH GC_NRF52_TWI GC_NRF52_DEV GC_NRF52_UART GREENCOMM_BT GREENCOMM_NUS BLE_STACK_SUPPORT_REQD BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET S132 NRF_LOG_USES_UART=1 NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x20002080 size 0xdf80
  group Application
    ../application/: main.c command.c print.c scc.c gc_time.c font.c flash_control.c gc_activity.c gc_comm.c gc_hr.c gc_protocol.c gc_util.c display.c gc_sleep.c gc_saadc.c gc_ble_notification.c
  group Board Support
    ../../bsp/: bsp.c bsp_btn_ble.c
  group nRF_BLE
    ../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../components/ble/ble_advertising/: ble_advertising.c
    ../../components/ble/ble_services/ble_nus/: ble_nus.c
    ../../components/ble/device_manager/: device_manager_peripheral.c
    ../../components/ble/ble_services/ble_ancs_c/: ble_ancs_c.c
    ../../components/ble/ble_db_discovery/: ble_db_discovery.c
  group nRF_Drivers
    ../../components/libraries/uart/: app_uart_fifo.c
    ../../components/drivers_nrf/delay/: nrf_delay.c
    ../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../components/drivers_nrf/pstorage/: pstorage.c
    ../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../../components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../../components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../../components/drivers_nrf/saadc/: nrf_drv_saadc.c
    ../../components/drivers_nrf/hal/: nrf_saadc.c
  group nRF_Libraries
    ../../components/libraries/button/: app_button.c
    ../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c nrf_log.c
    ../../components/libraries/fifo/: app_fifo.c
    ../../components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../../components/libraries/fstorage/: fstorage.c
    ../../components/libraries/uart/: retarget.c
    ../../components/libraries/scheduler/: app_scheduler.c
  group nRF_Segger_RTT
    ../../external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../components/softdevice/s132/doc/: s132_nrf52_2.0.0_licence_agreement.txt
    ../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group Dfu
    ../../components/libraries/bootloader_dfu/: bootloader_util.c dfu_app_handler.c bootloader.c
    ../../components/ble/ble_services/ble_dfu/: ble_dfu.c
  group gc_Drivers
    ../drivers/: bma2x2.c bma2x2_support.c oled.c rtc.c spi_flash.c afe4400.c an520.c pah8002.c pah8002_comm_i2c.c pah8002_comm_spi.c gc_twi.c twi_pah8002.c gc_capsense.c spi_pah8002.c
  group gc_Lib
    ../lib/: pah8series_motion5_181_m4f_keil.lib
  group RTT
    C:/Keil_v5/ARM/Pack/NordicSemiconductor/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    C:/Keil_v5/ARM/Pack/NordicSemiconductor/Syscalls/: RTT_Syscalls_KEIL.c
target flash_s132_nrf52_2.0.0_softdevice (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: as above
  output: s132_nrf52_2.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c include: ..\..\..\config\ble_app_uart_s132_pca10040;..\..\..\config
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x20002080 size 0xdf80
software components: CMSIS:CORE 4.3.0, Device:Startup 8.5.0
